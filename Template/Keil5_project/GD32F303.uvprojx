# Keil uVision project GD32F303.uvprojx, settings and files
target GD32F30X (6240000::V6.24::ARMCLANG)
  device: GD32F303VE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.5.0
  cpu: IRAM(0x20000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\..\Firmware\CMSIS;..\..\Firmware\CMSIS\GD\GD32F30x\Include;..\..\Firmware\GD32F30x_standard_peripheral\Include;..\..\Utilities;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x32000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ../: gd32f30x_it.c main.c systick.c gd32f30x_it.h gd32f30x_libopt.h main.h systick.h
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Peripherals
    ../../Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s startup_gd32f30x_hd.s startup_gd32f30x_xd.s
  group Utilities
    ../../Utilities/: gd32f307c_eval.c
  group Doc
    ../: readme.txt
  group Rtt
    ../../Source/rtt/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group App
    ../../Source/app/app_timer/: app_timer.c app_timer.h
    ../../Source/app/app_evenbus/: app_eventbus.c app_eventbus.h
    ../../Source/app/app_protocol/: app_protocol.c app_protocol.h
    ../../Source/app/app_public_protocol/: app_public_protocol.c app_public_protocol.h app_display_protocol.c app_display_protocol.h app_public.h
    ../../Source/app/app_public_config/: app_public_config.c app_public_config.h
    ../../Source/app/app_base/: app_base.c app_base.h
    ../../Source/app/app_network_model/: app_http_ota.c app_http_ota.h app_network_model.c app_network_model.h app_network_info.h
    ../../Source/app/app_md5/: app_md5.c app_md5.h
    ../../Source/app/app_token/: app_token.c app_token.h
    ../../Source/app/app_watchdog/: app_watchdog.c app_watchdog.h
    ../../Source/app/app_rtc/: app_rtc.c app_rtc.h
  group Bsp
    ../../Source/bsp/bsp_usart/: bsp_usart.c bsp_usart.h
    ../../Source/bsp/bsp_gpio/: bsp_gpio.c bsp_gpio.h
    ../../Source/bsp/bsp_pcb/: bsp_pcb.c bsp_pcb.h
    ../../Source/bsp/bsp_flash/: bsp_flash.c bsp_flash.h
    ../../Source/bsp/bsp_adc/: bsp_adc.c bsp_adc.h
    ../../Source/bsp/bsp_board/: bsp_board.c bsp_board.h
    ../../Source/bsp/bsp_i2c/: bsp_i2c.c bsp_i2c.h
  group Ethernet
    ../../Source/w5500/ioLibrary_Driver/Ethernet/: socket.c socket.h wizchip_conf.c wizchip_conf.h
    ../../Source/w5500/ioLibrary_Driver/Ethernet/W5500/: w5500.c w5500.h
  group Ithernet
    ../../Source/w5500/ioLibrary_Driver/Internet/DHCP/: dhcp.c dhcp.h
    ../../Source/w5500/ioLibrary_Driver/Internet/DNS/: dns.c dns.h
    ../../Source/w5500/ioLibrary_Driver/Internet/MQTT/: mqtt_interface.c mqtt_interface.h MQTTClient.c MQTTClient.h
    ../../Source/w5500/ioLibrary_Driver/Internet/MQTT/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTFormat.h MQTTPacket.c MQTTPacket.h MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group W5500
    ../../Source/w5500/wiz_interface/: wiz_interface.c wiz_interface.h
    ../../Source/w5500/ioLibrary_Driver/Internet/DNS/: do_dns.c do_dns.h
    ../../Source/w5500/wiz_platform/: wiz_platform.c wiz_platform.h
  group CJSON
    ../../Source/cjson/: cJSON.c cJSON.h
  group Dve
    ../../Source/dev/: dev_manager.c dev_manager.h dev_public_host.c dev_public_host.h dev_info.c dev_info.h
software components: CMSIS:CORE 6.1.1
