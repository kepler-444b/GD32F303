# Keil uVision project Project.uvprojx, settings and files
target GD32F30X_HD (6240000::V6.24::ARMCLANG)
  device: GD32F303VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.5.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F30X_HD
  c include: ..\..\Firmware\CMSIS;..\..\Firmware\CMSIS\GD\GD32F30x\Include;..\..\Firmware\GD32F30x_standard_peripheral\Include;..\..\Utilities;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application
    ../: gd32f30x_it.c main.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group Peripherals
    ../../Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_usart.c gd32f30x_wwdgt.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s startup_gd32f30x_hd.s startup_gd32f30x_xd.s
  group Utilities
    ../../Utilities/: gd32f307c_eval.c
  group Doc
    ../: readme.txt
  group Rtt
    ../../Source/rtt/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_RTT_printf.c
  group App
    ../../Source/app/app_timer/: app_timer.c app_timer.h
    ../../Source/app/app_panel_protocol/: app_panel_protocol.c app_panel_protocol.h
    ../../Source/app/app_w5500/: app_w5500.c app_w5500.h
    ../../Source/app/app_evenbus/: app_eventbus.c app_eventbus.h
    ../../Source/app/app_panel_config/: app_panel_config.c app_panel_config.h
  group Bsp
    ../../Source/bsp/bsp_usart/: bsp_usart.c bsp_usart.h
  group Cjson
    ../../Source/cjson/: cJSON.c cJSON.h
software components: CMSIS:CORE 6.1.1
